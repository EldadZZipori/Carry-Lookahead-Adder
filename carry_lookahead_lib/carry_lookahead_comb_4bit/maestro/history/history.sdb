<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Nov 26 17:34:30 2024</timestamp>
			<uuid>{ba2fa19c-1207-4c07-ac37-dde5576b6874}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/ubc/ece/home/ugrads/e/eldadzz/Desktop/ELEC402/project1_elec402/carry_lookahead_comb_4bit/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/ubc/ece/home/ugrads/e/eldadzz/Desktop/ELEC402/project1_elec402/carry_lookahead_comb_4bit/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/ubc/ece/home/ugrads/e/eldadzz/simulation/project1_elec402/carry_lookahead_comb_4bit/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/project1_elec402/carry_lookahead_comb_4bit/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
